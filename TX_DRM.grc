options:
  parameters:
    generate_options: qt_gui
    id: TX_DRM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: chan
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    label0: MSC
    label1: FAC
    label2: SDC
    num_opts: '3'
    option1: FAC
    option2: SDC
    type: string
    value: MSC
  states: {}
- name: in_val
  id: variable_qtgui_chooser
  parameters:
    label: Input
    label0: DRM
    label1: Wave
    label2: Sound
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: items_int_write
  id: variable
  parameters:
    value: '400'
  states: {}
- name: mod_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '113779'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency of Transmitted signal
    orient: Qt.Horizontal
    start: '0'
    step: '500'
    stop: '16000'
    value: '1000'
  states: {}
- name: DRM_Cyclic_Prefix_Add_0
  id: DRM_Cyclic_Prefix_Add
  parameters:
    length: '28'
  states: {}
- name: DRM_FAC_Source_0
  id: DRM_FAC_Source
  parameters:
    msc_modulation: '0'
    num_audio_services: '1'
    num_data_services: '0'
    sdc_code_rate: '0'
  states: {}
- name: DRM_IFFT_0
  id: DRM_IFFT
  parameters: {}
  states: {}
- name: DRM_PRBS_Dispersal_0
  id: DRM_PRBS_Dispersal
  parameters:
    channel: MSC
  states: {}
- name: DRM_PRBS_Dispersal_1
  id: DRM_PRBS_Dispersal
  parameters:
    channel: FAC
  states: {}
- name: DRM_PRBS_Dispersal_1_0
  id: DRM_PRBS_Dispersal
  parameters:
    channel: SDC
  states: {}
- name: DRM_QAM4_Mapper_0
  id: DRM_QAM4_Mapper
  parameters: {}
  states: {}
- name: DRM_QAM4_Mapper_0_0
  id: DRM_QAM4_Mapper
  parameters: {}
  states: {}
- name: DRM_QAM4_Mapper_0_0_0
  id: DRM_QAM4_Mapper
  parameters: {}
  states: {}
- name: DRM_SDC_Source_0
  id: DRM_SDC_Source
  parameters:
    data_entity_type: '0'
  states: {}
- name: DRM_Spectral_Efficiency_0
  id: DRM_Spectral_Efficiency
  parameters: {}
  states: {}
- name: DRM_c_encoder_0
  id: DRM_c_encoder
  parameters:
    channel: MSC
  states: {state: disabled}
- name: DRM_c_encoder_0_0
  id: DRM_c_encoder
  parameters:
    channel: FAC
  states: {state: disabled}
- name: DRM_c_encoder_0_0_0
  id: DRM_c_encoder
  parameters:
    channel: SDC
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Upconversion
    amp: '1'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: '113779'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: '113779'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tx_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: '5000'
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_1_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_1_0_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: in_val
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: TF_Start
    name: Transmission Frame
    type: complex
  states: {}
- name: blocks_tag_debug_1_0_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: Symbol_Start
    name: OFDM Symbol
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (2,1,2,1)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lindelani/Downloads/02. John Redcorn - (SongsLover.com).wav
    repeat: 'True'
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: int
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    type: int
  states: {}
- name: blocks_xor_xx_0_0_0
  id: blocks_xor_xx
  parameters:
    type: int
  states: {}
- name: note_0
  id: note
  parameters:
    note: To SDR
  states: {}
- name: note_1
  id: note
  parameters:
    note: PRBS-9
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '1'
    bw0: '100000'
    freq0: '90000000'
    gain0: '1000'
    if_gain0: '1'
    sample_rate: samp_rate*100
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Transmitted Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Real Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Imaginary Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: OFDM_Signal
  states: {state: disabled}

connections:
- [DRM_Cyclic_Prefix_Add_0, '0', blocks_complex_to_imag_0, '0']
- [DRM_Cyclic_Prefix_Add_0, '0', blocks_complex_to_real_0, '0']
- [DRM_FAC_Source_0, '0', blocks_xor_xx_0_0, '0']
- [DRM_IFFT_0, '0', DRM_Cyclic_Prefix_Add_0, '0']
- [DRM_IFFT_0, '0', blocks_tag_debug_1_0, '0']
- [DRM_IFFT_0, '0', blocks_tag_debug_1_0_0, '0']
- [DRM_PRBS_Dispersal_0, '0', blocks_float_to_int_0, '0']
- [DRM_PRBS_Dispersal_1, '0', blocks_float_to_int_1_0, '0']
- [DRM_PRBS_Dispersal_1_0, '0', blocks_float_to_int_1_0_0, '0']
- [DRM_QAM4_Mapper_0, '0', DRM_IFFT_0, '0']
- [DRM_QAM4_Mapper_0_0, '0', DRM_IFFT_0, '1']
- [DRM_QAM4_Mapper_0_0_0, '0', DRM_IFFT_0, '2']
- [DRM_QAM4_Mapper_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [DRM_SDC_Source_0, '0', blocks_xor_xx_0_0_0, '1']
- [DRM_c_encoder_0, '0', DRM_QAM4_Mapper_0, '0']
- [DRM_c_encoder_0_0, '0', DRM_QAM4_Mapper_0_0, '0']
- [DRM_c_encoder_0_0_0, '0', DRM_QAM4_Mapper_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0_1, '0']
- [analog_random_source_x_0, '0', blocks_xor_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_selector_0, '1']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_selector_0, '2']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_int_0, '0', blocks_xor_xx_0, '0']
- [blocks_float_to_int_1_0, '0', blocks_xor_xx_0_0, '1']
- [blocks_float_to_int_1_0_0, '0', blocks_xor_xx_0_0_0, '0']
- [blocks_int_to_float_0, '0', DRM_QAM4_Mapper_0, '0']
- [blocks_int_to_float_0, '0', DRM_c_encoder_0, '0']
- [blocks_int_to_float_0_0, '0', DRM_QAM4_Mapper_0_0, '0']
- [blocks_int_to_float_0_0, '0', DRM_c_encoder_0_0, '0']
- [blocks_int_to_float_0_0_0, '0', DRM_QAM4_Mapper_0_0_0, '0']
- [blocks_int_to_float_0_0_0, '0', DRM_c_encoder_0_0_0, '0']
- [blocks_int_to_float_0_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_null_source_0, '0', blocks_throttle_0_1, '0']
- [blocks_selector_0, '0', analog_wfm_tx_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0_1, '0', blocks_null_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_selector_0, '1']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [blocks_xor_xx_0, '0', blocks_int_to_float_0, '0']
- [blocks_xor_xx_0_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_xor_xx_0_0_0, '0', blocks_int_to_float_0_0_0, '0']
- [rational_resampler_xxx_0, '0', DRM_Spectral_Efficiency_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
